# Keil uVision project lvgl_831_optimize_lib.uvprojx, settings and files
target GRxx_Soc (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.5.1
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: lvgl_831_optimize_lib +hex (library)
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: GR5526_SK,ENV_USE_FREERTOS,ENABLE_DFU_SPI_FLASH,DFU_V2,USE_EXTERNAL_RESOURCES=1 GR5625_SK
  c misc: --no-multibyte-chars
  c include: ..\Src\config;..\..\..\..\..\platform\include;..\..\..\..\..\platform\soc\include;..\..\..\..\..\platform\arch\arm\cortex-m\cmsis\core\include;..\..\..\..\..\platform\soc\linker\keil;..\..\..\..\..\platform\boards;..\..\..\..\..\components\libraries\app_graphics_mem;..\..\..\..\..\components\boards;..\..\..\..\..\components\drivers_ext\gr55xx;..\..\..\..\..\components\drivers_ext\st7735;..\..\..\..\..\components\drivers_ext\vs1005;..\..\..\..\..\components\libraries\app_alarm;..\..\..\..\..\components\libraries\app_assert;..\..\..\..\..\components\libraries\app_error;..\..\..\..\..\components\libraries\app_key;..\..\..\..\..\components\libraries\app_log;..\..\..\..\..\components\libraries\app_queue;..\..\..\..\..\components\libraries\app_timer;..\..\..\..\..\components\libraries\at_cmd;..\..\..\..\..\components\libraries\dfu_master;..\..\..\..\..\components\libraries\dfu_port;..\..\..\..\..\components\libraries\gui;..\..\..\..\..\components\libraries\gui\gui_config;..\..\..\..\..\components\libraries\hal_flash;..\..\..\..\..\components\libraries\hci_uart;..\..\..\..\..\components\libraries\pmu_calibration;..\..\..\..\..\components\libraries\ring_buffer;..\..\..\..\..\components\libraries\sensorsim;..\..\..\..\..\components\libraries\utility;..\..\..\..\..\components\patch\ind;..\..\..\..\..\components\profiles\ams_c;..\..\..\..\..\components\profiles\ancs_c;..\..\..\..\..\components\profiles\ans;..\..\..\..\..\components\profiles\ans_c;..\..\..\..\..\components\profiles\bas;..\..\..\..\..\components\profiles\bas_c;..\..\..\..\..\components\profiles\bcs;..\..\..\..\..\components\profiles\bps;..\..\..\..\..\components\profiles\common;..\..\..\..\..\components\profiles\cscs;..\..\..\..\..\components\profiles\cts;..\..\..\..\..\components\profiles\cts_c;..\..\..\..\..\components\profiles\dis;..\..\..\..\..\components\profiles\dis_c;..\..\..\..\..\components\profiles\gls;..\..\..\..\..\components\profiles\gus;..\..\..\..\..\components\profiles\gus_c;..\..\..\..\..\components\profiles\hids;..\..\..\..\..\components\profiles\hrrcps;..\..\..\..\..\components\profiles\hrs;..\..\..\..\..\components\profiles\hrs_c;..\..\..\..\..\components\profiles\hts;..\..\..\..\..\components\profiles\ias;..\..\..\..\..\components\profiles\lls;..\..\..\..\..\components\profiles\ndcs;..\..\..\..\..\components\profiles\otas;..\..\..\..\..\components\profiles\otas_c;..\..\..\..\..\components\profiles\pass;..\..\..\..\..\components\profiles\pass_c;..\..\..\..\..\components\profiles\pcs;..\..\..\..\..\components\profiles\rscs;..\..\..\..\..\components\profiles\rscs_c;..\..\..\..\..\components\profiles\rtus;..\..\..\..\..\components\profiles\sample;..\..\..\..\..\components\profiles\ths;..\..\..\..\..\components\profiles\ths_c;..\..\..\..\..\components\profiles\thscps;..\..\..\..\..\components\profiles\tps;..\..\..\..\..\components\profiles\wechat;..\..\..\..\..\components\sdk\;..\..\..\..\..\components\drivers_ext\graphics_dc;..\..\..\..\..\components\drivers_ext\qspi_device\;..\..\..\..\..\components\graphics\gfx\common\;..\..\..\..\..\components\graphics\gfx\common\mem;..\..\..\..\..\components\graphics\gfx\configure;..\..\..\..\..\components\graphics\gfx\include;..\..\..\..\..\components\graphics\gfx\include\tsi;..\..\..\..\..\components\graphics\gfx\include\tsi\common;..\..\..\..\..\components\graphics\gfx\include\tsi\hal_gdc;..\..\..\..\..\components\graphics\gfx\include\tsi\hal_gfx;..\..\..\..\..\components\graphics\gfx\hal_gdc;..\..\..\..\..\components\graphics\gfx\hal_gfx;..\..\..\..\..\components\graphics\gfx\porting;..\..\..\..\..\components\libraries\app_graphics_mem;..\..\..\..\..\components\libraries\btxxxxx;..\..\..\..\..\components\libraries\bt_v2;..\..\..\..\..\components\libraries\fault_trace;..\..\..\..\..\drivers\inc;..\..\..\..\..\drivers\inc\hal;..\..\..\..\..\external\freertos\include;..\..\..\..\..\external\freertos\portable\RVDS\ARM_CM4F;..\..\..\..\..\external\segger_rtt;..\Src\lvgl_831;..\Src\lvgl_831\src;..\Src\lvgl_831\src\core;..\Src\lvgl_831\src\draw;..\Src\lvgl_831\src\draw\sw;..\Src\lvgl_831\src\extra;..\Src\lvgl_831\src\extra\layouts;..\Src\lvgl_831\src\extra\layouts\flex;..\Src\lvgl_831\src\extra\layouts\grid;..\Src\lvgl_831\src\extra\libs;..\Src\lvgl_831\src\extra\libs\bmp;..\Src\lvgl_831\src\extra\libs\freetype;..\Src\lvgl_831\src\extra\libs\fsdrv;..\Src\lvgl_831\src\extra\libs\gif;..\Src\lvgl_831\src\extra\libs\png;..\Src\lvgl_831\src\extra\libs\qrcode;..\Src\lvgl_831\src\extra\libs\rlottie;..\Src\lvgl_831\src\extra\libs\sjpg;..\Src\lvgl_831\src\extra\others;..\Src\lvgl_831\src\extra\others\snapshot;..\Src\lvgl_831\src\extra\themes;..\Src\lvgl_831\src\extra\themes\basic;..\Src\lvgl_831\src\extra\themes\default;..\Src\lvgl_831\src\extra\themes\mono;..\Src\lvgl_831\src\extra\widgets;..\Src\lvgl_831\src\extra\widgets\animimg;..\Src\lvgl_831\src\extra\widgets\calendar;..\Src\lvgl_831\src\extra\widgets\chart;..\Src\lvgl_831\src\extra\widgets\colorwheel;..\Src\lvgl_831\src\extra\widgets\imgbtn;..\Src\lvgl_831\src\extra\widgets\keyboard;..\Src\lvgl_831\src\extra\widgets\led;..\Src\lvgl_831\src\extra\widgets\list;..\Src\lvgl_831\src\extra\widgets\menu;..\Src\lvgl_831\src\extra\widgets\meter;..\Src\lvgl_831\src\extra\widgets\msgbox;..\Src\lvgl_831\src\extra\widgets\span;..\Src\lvgl_831\src\extra\widgets\spinbox;..\Src\lvgl_831\src\extra\widgets\spinner;..\Src\lvgl_831\src\extra\widgets\tabview;..\Src\lvgl_831\src\extra\widgets\tileview;..\Src\lvgl_831\src\extra\widgets\win;..\Src\lvgl_831\src\font;..\Src\lvgl_831\src\misc;..\Src\lvgl_831\src\widgets;..\Src\lvgl_831\src\hal;..\Src\lvgl_831\src\gpu;..\Src\lvgl_831\src\gpu\goodix;..\Src\lvgl_831\src\gpu\gr552x\porting;..\Src\app_font;..\Src\app_image;..\Src\app_layout;..\Src\app_main;..\Src\app_profiles;..\Src\app_tasks;..\Src\config;..\Src\dev_drivers;..\Src\lvgl_port;..\Src\system
  memory RVCT4: ROM 0x38000 size 0x28000
  memory RVCT9: RAM 0x2000a000 size 0x36000
  scatter file: ..\Src\linker\flash_scatter_watch_demo.sct
  link misc: ..\..\..\..\..\platform\soc\linker\keil\rom_symbol.txt
  group lvgl.optimize
    ../Src/lvgl_831_optimize/: opt_lv_obj.c opt_lv_indev_scroll.c opt_lv_obj_pos.c opt_lv_obj_style_gen.c opt_lv_refr.c opt_lv_draw_sw_letter.c opt_lv_font.c opt_lv_draw_label.c
